SRC_URI += "file://user_2019-06-05-13-38-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

